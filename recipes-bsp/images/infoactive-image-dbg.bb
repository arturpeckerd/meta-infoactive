require infoactive-image.bb

# debug tools
IMAGE_INSTALL += " strace evtest imx-test i2c-tools gdb gdbserver nfs-utils util-linux openssh"
