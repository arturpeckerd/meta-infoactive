include gst-infoactive.inc

SRC_URI = "file://${PN}-${PV}.tar.gz"

#S = "${WORKDIR}/${PN}-${PV}"
